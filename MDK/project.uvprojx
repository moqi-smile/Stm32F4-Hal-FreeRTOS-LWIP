# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\Driver\STM32F4xx_HAL_Driver\Inc;..\Driver\STM32F4xx_HAL_Driver\Inc\Legacy;..\Driver\CMSIS\Device\ST\STM32F4xx\Include;..\Driver\CMSIS\Include;..\Inc;..\MDK;..\Application;..\Application\Lib;..\Application\Eval;..\Application\Peripheral;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\Lwip\src\include\ipv4;..\Middlewares\Lwip\src\include\lwip;..\Middlewares\Lwip\src\include\netif;..\Middlewares\Lwip\src\include;..\Middlewares\Lwip\system;..\Middlewares\Lwip\App;..\Middlewares\Mqtt\src;..\Middlewares\Mqtt\samples;..\Middlewares\Mqtt\Client
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/CMSIS
    ../Driver/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../src/: system_stm32f4xx.c
  group Driver/STM32F4xx_HAL_Driver
    ../Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_eth.c
  group MDK/User
    ../src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Middlewares/FreeRTOS/Source
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Ports
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Lwip/Core/Ipv4
    ../Middlewares/Lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/Lwip/Core
    ../Middlewares/Lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group Middlewares/Lwip/Netif
    ../Middlewares/Lwip/src/netif/: etharp.c slipif.c
  group Middlewares/Lwip/Api
    ../Middlewares/Lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Lwip/Os
    ../Middlewares/Lwip/system/OS/: sys_arch.c
  group Middlewares/Lwip/App/Http
    ../Middlewares/Lwip/App/Http/: fs.c httpd.c
  group Middlewares/Mqtt/samples
    ../Middlewares/Mqtt/samples/: transport.c
    ../Middlewares/Mqtt/Client/: MqttClient.c
  group Middlewares/Mqtt/Src
    ../Middlewares/Mqtt/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Application/Peripheral
    ../Application/Peripheral/Sram/: Sram.c
  group Application/Eval
    ../Application/Eval/Gpio/: Gpio.c
    ../Application/Eval/Uart/: Uart.c
    ../Application/Eval/Ethernet/: ethernetif.c
  group Application/Lib
    ../Application/Lib/MALLOC/: MALLOC.c
    ../Application/Lib/JSON/: cJSON.c
  group Application
    ../Application/: Application.c LwipApplication.c HttpApplication.c MqttApplication.c
